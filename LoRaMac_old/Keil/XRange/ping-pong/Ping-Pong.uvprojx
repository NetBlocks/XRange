# Keil uVision project Ping-Pong.uvprojx, settings and files
target Ping-Pong-868-lora (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ping-Pong +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_868 USE_MODEM_LORA
  c include: ..\..\..\src;..\..\..\src\boards\LoRaMote;..\..\..\src\boards\LoRaMote\cmsis;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L1xx_StdPeriph_Driver\inc;..\..\..\src\mac;..\..\..\src\peripherals;..\..\..\src\radio;..\..\..\src\system;..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group apps
    ../../../src/apps/ping-pong/XRange/: main.c
  group boards\LoRaMote
    ../../../src/boards/LoRaMote/: board.c gpio-board.c rtc-board.c spi-board.c sx1272-board.c timer-board.c
  group boards\LoRaMote\cmsis
    ../../../src/boards/LoRaMote/cmsis/arm-std/: startup_stm32l1xx_md.s
    ../../../src/boards/LoRaMote/cmsis/: system_stm32l1xx.c
  group boards\LoRaMote\STM32L1xx_StdPeriph_Driver
    ../../../src/boards/mcu/stm32/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
  group boards\mcu\stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group radio
    ../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../src/system/: delay.c fifo.c gpio.c timer.c
target Ping-Pong-868-fsk (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_868 USE_MODEM_FSK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target Ping-Pong-868-lora-Bootloader (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_868 USE_MODEM_LORA USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target Ping-Pong-868-fsk-Bootloader (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_868 USE_MODEM_FSK USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target Ping-Pong-915-lora (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_915 USE_MODEM_LORA
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target Ping-Pong-915-fsk (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_915 USE_MODEM_FSK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target Ping-Pong-915-lora-Bootloader (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_915 USE_MODEM_LORA USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target Ping-Pong-915-fsk-Bootloader (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_BAND_915 USE_MODEM_FSK USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
