# Keil uVision project LoRaMac.uvproj, settings and files
target LoRaMac-868 (ARM-ADS)
  device: STM32L151CC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LoRaMac +hex
  c flags: Optim=3 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xC USE_DEBUGGER USE_BAND_868 USE_USB_CDC
  c include: ..\..\..\..\src;..\..\..\..\src\boards\XRange;..\..\..\..\src\boards\XRange\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\inc;..\..\..\..\src\mac;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto;..\..\..\..\src\boards\XRange\usb\cdc\inc;..\..\..\..\src\boards\mcu\stm32\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\..\src\boards\mcu\stm32\STM32_USB_Device_Library\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group apps
    ../../../../src/apps/LoRaMac/classA-usb/XRange/: main.c
  group boards\XRange
    ../../../../src/boards/XRange/: adc-board.c board.c gpio-board.c i2c-board.c rtc-board.c spi-board.c sx1272-board.c uart-board.c usb-printf.c tiny_vsnprintf.c
  group boards\LoRaMote\cmsis
    ../../../../src/boards/XRange/cmsis/: system_stm32l1xx.c
    ../../../../src/boards/XRange/cmsis/arm-std/: startup_stm32l151xc.s
  group boards\LoRaMote\STM32L1xx_HAL_Driver
    ../../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c
  group boards\mcu\stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group radio
    ../../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../../src/system/: adc.c delay.c fifo.c gpio.c i2c.c timer.c uart.c
    ../../../../src/boards/XRange/: uart-usb-board.c
  group system\crypto
    ../../../../src/system/crypto/: aes.c cmac.c
  group USB Lib
    ../../../../src/boards/mcu/stm32/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../../src/boards/mcu/stm32/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../src/boards/XRange/usb/cdc/src/: usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group cli
    ../../../../src/apps/LoRaMac/classA-usb/XRange/: cli.c cmdline.c utils.c eeprom_conf.c
target LoRaMac-915 (ARM-ADS)
  device: STM32L151CC STMicroelectronics
  cpu: as above
  output: LoRaMac +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xC USE_DEBUGGER USE_BAND_915 USE_USB_CDC
  c include: ..\..\..\..\src;..\..\..\..\src\boards\XRange;..\..\..\..\src\boards\XRange\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\inc;..\..\..\..\src\mac;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto;..\..\..\..\src\boards\mcu\stm32\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\..\src\boards\mcu\stm32\STM32_USB_Device_Library\Core\Inc;..\..\..\..\src\boards\XRange\usb\cdc\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
