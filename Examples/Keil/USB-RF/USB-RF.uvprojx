# Keil uVision project USB-RF.uvprojx, settings and files
target XRange (ARM-ADS)
  device: STM32L151CC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB-RF +hex
  c flags: Optim=2 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\inc;..\..\SPL\inc;..\..\src\xrange;..\..\src\radio;..\..\cmsis;..\..\src;..\..\STM32_USB-FS-Device_Driver\inc;..\..\usb\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group SPL
    ../../SPL/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group radio
    ../../src/radio/: radio.c sx1272.c sx1272-Fsk.c sx1272-FskMisc.c sx1272-LoRa.c sx1272-LoRaMisc.c
  group xrange
    ../../src/xrange/: led.c rtc.c spi.c stm32fxxx_it.c sx1272-Hal.c utility.c XRange-Hal.c
  group app
    ../../src/: system_stm32l1xx.c startup_stm32l1xx_hd_keil.s
    ../../apps/USB-RF/: main.c
  group usb_lib
    ../../STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group usb
    ../../usb/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
