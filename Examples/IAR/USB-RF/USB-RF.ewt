<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <file>
      <name>$PROJ_DIR$\..\..\apps\USB-RF\main.c</name>
    </file>
  </group>
  <group>
    <name>radio</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\radio\radio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\radio\sx1272-Fsk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\radio\sx1272-FskMisc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\radio\sx1272-LoRa.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\radio\sx1272-LoRaMisc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\radio\sx1272.c</name>
    </file>
  </group>
  <group>
    <name>SPL</name>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_aes_util.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_flash_ramfunc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_opamp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\SPL\src\stm32l1xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>STM32_USB-FS-Device_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\STM32_USB-FS-Device_Driver\src\usb_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM32_USB-FS-Device_Driver\src\usb_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM32_USB-FS-Device_Driver\src\usb_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM32_USB-FS-Device_Driver\src\usb_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM32_USB-FS-Device_Driver\src\usb_regs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM32_USB-FS-Device_Driver\src\usb_sil.c</name>
    </file>
  </group>
  <group>
    <name>usb</name>
    <file>
      <name>$PROJ_DIR$\..\..\usb\src\hw_config.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb\src\usb_desc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb\src\usb_endp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb\src\usb_istr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb\src\usb_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb\src\usb_prop.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb\src\usb_pwr.c</name>
    </file>
  </group>
  <group>
    <name>xrange</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\xrange\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\platform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\xrange\rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\xrange\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\startup_stm32l152xc.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\xrange\stm32fxxx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\xrange\sx1272-Hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\system_stm32l1xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\xrange\utility.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\xrange\XRange-Hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\xrange-hw-ver.h</name>
    </file>
  </group>
</project>


