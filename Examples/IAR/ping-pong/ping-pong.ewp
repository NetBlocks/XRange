# IAR project ping-pong.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xC ST STM32L152xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\apps\ping-pong; ..\..\cmsis; ..\..\inc; ..\..\SPL\inc; ..\..\src\radio; ..\..\src\xrange; ..\..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L151xC ST STM32L151xC
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32L1XX
  ICCARM.CCOptLevel: 3
  group app
    ../../apps/ping-pong/: main.c
  group radio
    ../../src/radio/: radio.c sx1272-Fsk.c sx1272-FskMisc.c sx1272-LoRa.c sx1272-LoRaMisc.c sx1272.c
  group SPL
    ../../SPL/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group xrange
    ../../src/xrange/: led.c rtc.c spi.c stm32fxxx_it.c sx1272-Hal.c utility.c XRange-Hal.c
    ../../src/: startup_stm32l152xc.s system_stm32l1xx.c
